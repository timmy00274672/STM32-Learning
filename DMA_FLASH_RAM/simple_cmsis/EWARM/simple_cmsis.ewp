# IAR project simple_cmsis.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCIncludePath2: $WS_DIR$\..\CMSIS_V1P10\Core\CM3; $WS_DIR$\..\FWLib\library\inc; $WS_DIR$\..\FWLib\project; $WS_DIR$\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: simple_cmsis.srec
  ILINK.IlinkOutputFile: simple_cmsis.out
  ILINK.IlinkIcfFile: $WS_DIR$\..\FWLib\project\EWARMv5\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS_Include
    ../../../CMSIS_V1P10/Core/CM3/: core_cm3.h stm32.h system_stm32.h
  group CMSIS_Source
    ../../../CMSIS_V1P10/Core/CM3/: core_cm3.c system_stm32.c
  group CMSIS_Startup
    ../../../CMSIS_V1P10/Core/CM3/startup/iar/: startup_stm32f10x.s
  group FWLib_src
    ../../../FWLib/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Include
    ../../inc/: main.h
  group Source
    ../../: main.c
